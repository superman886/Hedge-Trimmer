# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507_Project (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\BSP;..\..\MSPM0G3507_Project1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c board.h
    ./: startup_mspm0g350x_uvision.s
  group BSP
    ../BSP/: IRtracking.c IRtracking.h Car.c Car.h hw_encoder.h hw_encoder.c dmpKey.h dmpmap.h bsp_tb6612.h bsp_tb6612.c ararm.h ararm.c inv_mpu.h inv_mpu.c bsp_mpu6050.c bsp_mpu6050.h inv_mpu_dmp_motion_driver.h inv_mpu_dmp_motion_driver.c hw_timer.c hw_timer.h
  group Driverlib
    ../ti/: dl_vref.c dl_uart.c dl_trng.c dl_timer.c dl_spi.c dl_rtc_common.c dl_opa.c dl_mcan.c dl_mathacl.c dl_lfss.c dl_lcd.c dl_keystorectl.c dl_i2c.c dl_flashctl.c dl_dma.c dl_dac12.c dl_crcp.c dl_crc.c dl_common.c dl_aesadv.c dl_aes.c dl_adc12.c
